Commit message: changed table color

File: robots/simple_table.xacro (robot description, xacro)
@@ -34,5 +34,5 @@
         <mu1>1</mu1>
         <mu2>1</mu2>
-        <material>Gazebo/Green</material>
+        <material>Gazebo/White</material>
     </gazebo>
 </robot>
